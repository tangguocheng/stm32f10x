# Keil uVision project STM32F10x.uvprojx, settings and files
target smart_home (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\src;..\lib\st_lib\cmsis;..\lib\st_lib\cmsis\startup;..\lib\st_lib\fwlib\inc;..\lib\FreeRTOS\Source\include;..\lib\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\lib\ioLibrary_Driver-master\Ethernet;..\lib\ioLibrary_Driver-master\Ethernet\W5500;..\lib\ioLibrary_Driver-master\Internet\DHCP;..\lib\freemodbus\stm32f103_port;..\lib\freemodbus\modbus\include;..\lib\freemodbus\modbus\tcp;..\src\task;..\src\BSP;..\src\APP;..\src\IAP;..\src\STM_FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x19000
  memory RVCT5: ROM 0x801c000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FreeRTOS
    ../lib/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../lib/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../lib/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group st_lib
    ../lib/st_lib/fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
    ../lib/st_lib/cmsis/: core_cm3.c system_stm32f10x.c
    ../lib/st_lib/cmsis/startup/: startup_stm32f10x_hd.s
  group main
    ../src/: main.c stm32f10x_it.c
  group board
    ../src/BSP/: bsp_led.c bsp_delay.c bsp_uart1.c bsp_board_gpio.c
  group task
    ../src/task/: task_485.c
  group APP
    ../src/APP/: CRC16.c
  group todo
    ../: todo.md
