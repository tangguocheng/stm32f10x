# Keil uVision project STM32F10x.uvprojx, settings and files
target smart_home (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\src;..\lib\st_lib\cmsis;..\lib\st_lib\cmsis\startup;..\lib\st_lib\fwlib\inc;..\lib\ioLibrary_Driver-master\Ethernet;..\lib\ioLibrary_Driver-master\Ethernet\W5500;..\lib\ioLibrary_Driver-master\Internet\DHCP;..\src\BSP;..\src\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ioLibrary_Driver/Ethernet
    ../lib/ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ../lib/ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
  group ioLibrary_Driver/Internet
    ../lib/ioLibrary_Driver-master/Internet/DHCP/: dhcp.c
  group STM_FLASH
    ../src/STM_FLASH/: stm_flash.c
  group AT24C08
    ../src/BSP/: 24c08.c
  group st_lib
    ../lib/st_lib/fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
    ../lib/st_lib/cmsis/: core_cm3.c system_stm32f10x.c
    ../lib/st_lib/cmsis/startup/: startup_stm32f10x_hd.s
  group main
    ../src/: main.c stm32f10x_it.c
  group board
    ../src/BSP/: delay.c w5500_port.c bsp_led.c timer.c
  group IAP
    ../src/IAP/: IAP.c
  group todo
    ../: todo.md
