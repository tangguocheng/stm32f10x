# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc;..\..\User\FreeRTOS\Source\include;..\..\User\FreeRTOS\Source\portable\MemMang;..\..\User\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\User\FreeModbus-V1.5\include;..\..\User\FreeModbus-V1.5\STM32F103-PORT;..\..\User\FreeModbus-V1.5\BARE\port;..\..\User\FreeModbus-V1.5\rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../User/app/src/: main.c
  group BSP
    ../../User/bsp/src/: bsp_led.c
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.c stm32f10x_assert.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
  group FreeRTOS
    ../../User/FreeRTOS/Source/: tasks.c queue.c list.c
    ../../User/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../User/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group FreeModbus-V1.5
    ../../User/FreeModbus-V1.5/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../User/FreeModbus-V1.5/rtu/: mbcrc.c mbrtu.c
    ../../User/FreeModbus-V1.5/: mb.c
  group FreeModbus-V1.5-PORT
    ../../User/FreeModbus-V1.5/BARE/port/: portevent.c portserial.c porttimer.c
    ../../User/FreeModbus-V1.5/BARE/: FreeModbus-V1.5-PORT_reg.C
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.1
